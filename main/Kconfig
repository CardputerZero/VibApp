## main/Kconfig
```kconfig
menu "VibApp"

config VIBAPP_PLACEHOLDER
    bool "Placeholder"
    default y

endmenu
```
